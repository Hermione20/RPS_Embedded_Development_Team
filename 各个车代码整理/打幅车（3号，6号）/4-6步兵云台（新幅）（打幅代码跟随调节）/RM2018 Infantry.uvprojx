# Keil uVision project RM2018 Infantry.uvprojx, settings and files
target RM2018 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2018_Infantry +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\APP;.\STLibraries;.\User;.\Protocol;.\FIFO;.\;.\Debug;.\RmLib;.\BSP\OLED;.\ICM20948;.\Proto;.\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./BSP/: bsp.c
    ./User/: main.c config.h
    ./: readme.txt
  group BSP
    ./BSP/: led.c gun.c can1.c can2.c delay.c exti.c laser.c timer.c usart1.c bsp_flash.c encoder.c output2vs.c key_scan.c uart4.c iwdg.c client.c adc.c hi220.c distance_measue.c protobuf-c.c Attack.pb-c.c pid.c Signal.pb-c.c TurretCommand.pb-c.c ch100_DMA.c
    ./BSP/OLED/: oled.c
    ./APP/: Judge.c
  group Libraries
    ./User/: stm32f4xx_it.c
    ./STLibraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c startup_stm32f4xx.s stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c stm32f4xx_i2c.c stm32f4xx_iwdg.c
  group Protocol
    ./Protocol/: Protocol.lib MF_CRC16.h protocal.h
  group Task
    ./APP/: ControlTask.c IOTask.c RemoteTask.c CanBusTask.c SuperviseTask.c modeswitch_task.c gimbal_task.c shoot_task.c chassis_task.c Auto_Shoot_Control_Task.c
  group RmLib
    ./RmLib/: common.h fifo.h LostCounter.h pid_regulator.h ramp.h RMLib.lib ramp_second.c
  group ICM20948
    ./ICM20948/: icm20948.c icm20948_driver.c spi.c AHRS_middleware.c AHRS.lib
  group kalman_filter
    ./APP/: kalman_filter.c buff_karman_filter.c autoshoot_karman_filter.c
  group proto
    ./Proto/: recieve.pb-c.c send.pb-c.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Compiler:I/O:STDERR 1.2.0
