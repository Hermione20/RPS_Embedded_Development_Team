# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\README;..\HEADFILE;..\STLIB\inc;..\STLIB\src;..\APP\BAL\Ins;..\APP\RTOS\Ins;..\APP\TASK\CHASSIS_TASK\Inc;..\APP\TASK\GIMBAL_TASK\Ins;..\BSP\can\Inc;..\BSP\delay\Inc;..\BSP\usart\Inc;..\BSP\sys\Inc;..\EMBEDDED\CAN_BUS;..\EMBEDDED\senior\CH100;..\EMBEDDED\senior\DJI_MOTOR;..\EMBEDDED\senior\HI220;..\EMBEDDED\senior\HT430;..\EMBEDDED\senior\JUDGE;..\EMBEDDED\senior\LK_TECH;..\EMBEDDED\senior\PM01;..\EMBEDDED\senior_struct;..\EMBEDDED\senior\REMOTE;..\APP\TASK\MODE_SWITCH_TASK\Inc;..\BSP\timer\Inc;..\EMBEDDED\senior\CAN_CHASSIS_TRANSMIT;..\EMBEDDED\senior\USART_chassis_transmit;..\BSP\LED\LED;..\APP\TASK\SHOOT_TASK\Inc;..\EMBEDDED\senior\Auto_Shoot;..\EMBEDDED\senior\OLD_Auto_shoot;..\EMBEDDED\senior\OLD_Auto_shoot\proto;..\EMBEDDED\senior\OLD_Auto_shoot\Protocol;..\EMBEDDED\senior\client;..\BSP\iwdg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c BSP.c
  group RTOS
    ../APP/RTOS/Src/: control_task.c
  group TASK
    ../APP/TASK/GIMBAL_TASK/Src/: buff_karman_filter.c gimbal_task.c
    ../APP/TASK/MODE_SWITCH_TASK/Sor/: infantry_mode_switch_task.c
    ../APP/TASK/SHOOT_TASK/Src/: 17mm_shoot_task.c
  group BAL
    ../APP/BAL/Src/: oldpid.c
  group EMBEDDED
    ../EMBEDDED/senior_struct/: senior.c
    ../EMBEDDED/CAN_BUS/: CanBus.c
    ../EMBEDDED/senior/CH100/: CH100.c
    ../EMBEDDED/senior/DJI_MOTOR/: DJI_MOTOR.c
    ../EMBEDDED/senior/HI220/: HI220.c
    ../EMBEDDED/senior/HT430/: HT430.c
    ../EMBEDDED/senior/JUDGE/: JUDGE.c
    ../EMBEDDED/senior/LK_TECH/: LK_TECH.c
    ../EMBEDDED/senior/PM01/: PM01.c
    ../EMBEDDED/senior/REMOTE/: REMOTE.c
    ../EMBEDDED/senior/CAN_CHASSIS_TRANSMIT/: can_chassis_transmit.c
    ../EMBEDDED/senior/USART_chassis_transmit/: USART_chassis_transmit.c
    ../EMBEDDED/senior/Auto_Shoot/: Auto_shoot.c
    ../EMBEDDED/senior/OLD_Auto_shoot/: OLD_Auto_shoot.c
    ../EMBEDDED/senior/OLD_Auto_shoot/proto/: protobuf-c.c Recieve.pb-c.c Send.pb-c.c
    ../EMBEDDED/senior/client/: client.c
  group BSP
    ../BSP/can/Src/: can.c
    ../BSP/delay/Src/: delay.c
    ../BSP/sys/Sor/: sys.c
    ../BSP/usart/Src/: usart.c
    ../BSP/timer/Src/: timer.c
    ../BSP/LED/LED/: led.c
    ../BSP/iwdg/: iwdg.c
  group HEADFILE
    ../HEADFILE/: main.h public.h
  group STLIB
    ../STLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group README
    ../: readme.txt
    ../README/: fifo.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Compiler:I/O:STDERR 1.2.0
